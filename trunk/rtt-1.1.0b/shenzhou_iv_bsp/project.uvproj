# Keil uVision project project.uvproj, settings and files
target rtt_sz_iv (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: rtthread-stm32 +hex
  c flags: Optim=1
  c define: STM32F10X_CL, USE_STDPERIPH_DRIVER
  c include: .;..\rt-thread_os\components\dfs;..\rt-thread_os\components\dfs\include;..\rt-thread_os\components\drivers\spi;..\rt-thread_os\components\drivers\include;..\rt-thread_os\components\finsh;..\rt-thread_os\components\net\lwip\src;..\rt-thread_os\components\net\lwip\src\arch\include;..\rt-thread_os\components\net\lwip\src\include;..\rt-thread_os\components\net\lwip\src\include\ipv4;..\rt-thread_os\components\net\lwip\src\include\netif;..\rt-thread_os\include;..\rt-thread_os\libcpu\arm\common;..\rt-thread_os\libcpu\arm\cortex-m3;.\FWLib\CMSIS\CM3\CoreSupport;.\FWLib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\FWLib\STM32F10x_StdPeriph_Driver\inc;.\Driver\
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*
  group Startup
    ./: application.c startup.c board.c stm32f10x_it.c rtconfig.h
  group Kernel
    ../rt-thread_os/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M3
    ../rt-thread_os/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../rt-thread_os/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    ../rt-thread_os/components/dfs/src/: dfs.c dfs_fs.c dfs_file.c dfs_posix.c
    ../rt-thread_os/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group finsh
    ../rt-thread_os/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group LwIP
    ../rt-thread_os/components/net/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../rt-thread_os/components/net/lwip/src/arch/: sys_arch.c
    ../rt-thread_os/components/net/lwip/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../rt-thread_os/components/net/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../rt-thread_os/components/net/lwip/src/netif/: etharp.c ethernetif.c slipif.c
  group STM32_StdPeriph
    FWLib/CMSIS/CM3/CoreSupport/: core_cm3.c
    FWLib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    FWLib/STM32F10x_StdPeriph_Driver/src/: stm32f10x_crc.c stm32f10x_rcc.c stm32f10x_wwdg.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_bkp.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_rtc.c stm32f10x_fsmc.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_sdio.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_can.c stm32f10x_cec.c misc.c
    FWLib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
  group Drivers
    ./driver/: stm32_eth.c serial.c usart.c board_sdio.c led.c rt_stm32f10x_spi.c spi_flash_w25qxx.c spi_sd.c
    ../rt-thread_os/components/drivers/spi/: spi_core.c spi_dev.c
  group TestUnit
    ../rt-thread_os/examples/test/: fs_test.c
